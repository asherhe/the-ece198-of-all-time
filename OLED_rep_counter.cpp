// @file OLED.cpp
// @author Philip Turturea
// @date 2026-11-09
// @version 1.2
// @since 1.2 Only redraws a display component when it changes, but
// 			  the entire display data is still sent to the OLED
// 			  every time display.display() is called
// @since 1.1 Displays user rep count (moved the timer to make room)
// 			  (and cleaned up comments)
// @since 1.0 Displays user heart rate (in BPM) inside a beating heart
//			  and a countdown timer until the end of the session
// @adapted from ECE 198 Lab 4 code (OLED initialization)
// 			and ADAfruit SSD1306 example code (bitmaps)

// testing observations:
// the OLED can use 3.3V or 5V
// the pixels are monochrome
// after making the pixel art in Krita, I used https://jlamch.net/MXChipWelcome/ for the bitmaps

// libraries
#include <Wire.h> // I2C
#include <Adafruit_GFX.h> // OLED
#include <Adafruit_SSD1306.h> // OLED

// declarations for custom functions
void draw_frame(bool big_or_small, bool update_timer);
void draw_heart(bool big_or_small);
void update_bpm();
void update_reps();
void update_timer();
void draw_timer();

// imported variables
unsigned int heart_rate = 60; // replace the RHS with the oximeter heart rate
bool safe_heart = true; // replace the RHS with the ECG calculation
unsigned int reps = 10; // replace the RHS with the rep count calculated by the accelerometer

// from testing: need to add UL to avoid an overflow (on 16-bit microcontrollers)
// since C++ treats the expression as an int (2 bytes)
unsigned long workout_time = (30UL*1000*60); // 30 minutes; the physician should be able to set this

// screen constants and object
const int SCREEN_WIDTH{128}; // instead of #define
const int SCREEN_HEIGHT{64};
const int OLED_RESET{-1};
Adafruit_SSD1306 display(SCREEN_WIDTH, SCREEN_HEIGHT, &Wire, OLED_RESET);

// heart constants (including bitmaps)
const int HEART_WIDTH{64};
const int HEART_HEIGHT{64};

static const unsigned char PROGMEM big_heart [] = {
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x3f, 0xf0, 0x00, 0x00, 0x0f, 0xfc, 0x00, 0x00, 0x3f, 0xf0, 0x00, 0x00, 0x0f, 0xfc, 0x00, 
	0x00, 0xff, 0xfc, 0x00, 0x00, 0x3f, 0xff, 0x00, 0x00, 0xff, 0xfc, 0x00, 0x00, 0x3f, 0xff, 0x00, 
	0x0f, 0xff, 0xff, 0x00, 0x00, 0xff, 0xff, 0xf0, 0x0f, 0xff, 0xff, 0x00, 0x00, 0xff, 0xff, 0xf0, 
	0x3f, 0xff, 0xff, 0xc0, 0x03, 0xff, 0xff, 0xfc, 0x3f, 0xff, 0xff, 0xc0, 0x03, 0xff, 0xff, 0xfc, 
	0xff, 0xff, 0xff, 0xf0, 0x0f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf0, 0x0f, 0xff, 0xff, 0xff, 
	0xff, 0xff, 0xff, 0xf0, 0x0f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf0, 0x0f, 0xff, 0xff, 0xff, 
	0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
	0xff, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xff, 0xff, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xff, 
	0xff, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 0xff, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 
	0xff, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 0xff, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 
	0xff, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 0xff, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 
	0x3f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xfc, 0x3f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xfc, 
	0x3f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xfc, 0x3f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xfc, 
	0x0f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xf0, 0x0f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xf0, 
	0x0f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xf0, 0x0f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xf0, 
	0x03, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xc0, 0x03, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xc0, 
	0x03, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xc0, 0x03, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xc0, 
	0x00, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 
	0x00, 0x3f, 0xff, 0xff, 0xff, 0xff, 0xfc, 0x00, 0x00, 0x3f, 0xff, 0xff, 0xff, 0xff, 0xfc, 0x00, 
	0x00, 0x0f, 0xff, 0xff, 0xff, 0xff, 0xf0, 0x00, 0x00, 0x0f, 0xff, 0xff, 0xff, 0xff, 0xf0, 0x00, 
	0x00, 0x03, 0xff, 0xff, 0xff, 0xff, 0xc0, 0x00, 0x00, 0x03, 0xff, 0xff, 0xff, 0xff, 0xc0, 0x00, 
	0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 
	0x00, 0x00, 0x3f, 0xff, 0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x3f, 0xff, 0xff, 0xfc, 0x00, 0x00, 
	0x00, 0x00, 0x03, 0xff, 0xff, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 0xff, 0xc0, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xff, 0xff, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x0f, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xf0, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
};

static const unsigned char PROGMEM small_heart [] = {
  	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x3f, 0xfc, 0x00, 0x00, 0x3f, 0xfc, 0x00, 0x00, 0x3f, 0xfc, 0x00, 0x00, 0x3f, 0xfc, 0x00, 
	0x03, 0xff, 0xff, 0x00, 0x00, 0xff, 0xff, 0xc0, 0x03, 0xff, 0xff, 0x00, 0x00, 0xff, 0xff, 0xc0, 
	0x0f, 0xff, 0xff, 0xc0, 0x03, 0xff, 0xff, 0xf0, 0x0f, 0xff, 0xff, 0xc0, 0x03, 0xff, 0xff, 0xf0, 
	0x3f, 0xff, 0xff, 0xf0, 0x0f, 0xff, 0xff, 0xfc, 0x3f, 0xff, 0xff, 0xf0, 0x0f, 0xff, 0xff, 0xfc, 
	0x3f, 0xff, 0xff, 0xf0, 0x0f, 0xff, 0xff, 0xfc, 0x3f, 0xff, 0xff, 0xf0, 0x0f, 0xff, 0xff, 0xfc, 
	0x3f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfc, 0x3f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfc, 
	0x3f, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xfc, 0x3f, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xfc, 
	0x3f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xfc, 0x3f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xfc, 
	0x3f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xfc, 0x3f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xfc, 
	0x3f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xfc, 0x3f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xfc, 
	0x0f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xf0, 0x0f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xf0, 
	0x0f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xf0, 0x0f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xf0, 
	0x03, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xc0, 0x03, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xc0, 
	0x03, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xc0, 0x03, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xc0, 
	0x00, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 
	0x00, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x0f, 0x00, 0x00, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x0f, 0x00, 
	0x00, 0x3f, 0xff, 0xff, 0xff, 0xff, 0xfc, 0x00, 0x00, 0x3f, 0xff, 0xff, 0xff, 0xff, 0xfc, 0x00, 
	0x00, 0x3f, 0xff, 0xff, 0xff, 0xff, 0xfc, 0x00, 0x00, 0x3f, 0xff, 0xff, 0xff, 0xff, 0xfc, 0x00, 
	0x00, 0x0f, 0xff, 0xff, 0xff, 0xff, 0xf0, 0x00, 0x00, 0x0f, 0xff, 0xff, 0xff, 0xff, 0xf0, 0x00, 
	0x00, 0x03, 0xff, 0xff, 0xff, 0xff, 0xc0, 0x00, 0x00, 0x03, 0xff, 0xff, 0xff, 0xff, 0xc0, 0x00, 
	0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 
	0x00, 0x00, 0x3f, 0xff, 0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x3f, 0xff, 0xff, 0xfc, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xff, 0xff, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x0f, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xf0, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
};

void setup() {
  // I2C
  display.begin(SSD1306_SWITCHCAPVCC, 0x3C);
  display.clearDisplay();
  display.setTextColor(SSD1306_WHITE);
}

// copied the following from ChatGPT
unsigned long previousTimeUpdate = 0;
unsigned long previousHeartUpdate = 0;

bool bigHeart = false;
bool firstFrame = true;

bool previousBigHeart = false;
bool previousSafeHeart = true;
unsigned int previousHeartRate = 0;
unsigned int previousReps = 0;

void loop() {
    unsigned long current_millis = millis();

    // Update clock every second
    if (current_millis - previousTimeUpdate >= 1000) {
        previousTimeUpdate = current_millis;
		update_timer();
        draw_frame(bigHeart, true);
    }

    // Animate heart independently and according to heart_rate
    unsigned long heartInterval;
	if (bigHeart) {
		heartInterval = (1600UL * 25UL) / heart_rate;
	} else {
		heartInterval = (800UL * 25UL) / heart_rate;
	}

    if (current_millis - previousHeartUpdate >= heartInterval) {
        previousHeartUpdate = current_millis;
        bigHeart = !bigHeart;

        draw_frame(bigHeart, false);
    }
}


void draw_frame(bool big_or_small, bool updateClock) {

    bool changed = false;

    // Update heart and BPM if either has changed
    if (firstFrame ||
        big_or_small != previousBigHeart ||
        safe_heart != previousSafeHeart ||
        (safe_heart && heart_rate != previousHeartRate)) {

        display.fillRect(0, 0, 64, 64, SSD1306_BLACK);

        update_bpm();
        draw_heart(big_or_small);

        previousBigHeart = big_or_small;
        previousSafeHeart = safe_heart;
        previousHeartRate = heart_rate;

        changed = true;
    }

    // Update timer once per second
    if (firstFrame || updateClock) {
        display.fillRect(64, 0, 64, 32, SSD1306_BLACK);
        draw_timer();
        changed = true;
    }

    // Update reps only if they have changed
    if (firstFrame || reps != previousReps) {
		// the 'Reps:' will not be drawn over since it is constant
        display.fillRect(103, 48, 25, 16, SSD1306_BLACK);
        update_reps();

        previousReps = reps;
        changed = true;
    }

    if (changed) {
        display.display();
    }

    firstFrame = false;
}

// copying ends

void draw_heart(bool big_or_small) {
  unsigned char const * heart = big_heart;

  if (big_or_small == false){
  heart = small_heart;
  }

  display.drawBitmap(
  0, (SCREEN_HEIGHT - HEART_HEIGHT),
  heart, HEART_WIDTH, HEART_HEIGHT, 1);
}

void update_bpm(){
  if (safe_heart == false){
	display.setCursor(15, 23);
	display.print("!!!");
  }
  else {
	if (heart_rate >= 100){
	display.setCursor(15, 23);
 	} else { // 2-digit heart rate
	display.setCursor(21, 23);
  	}

	display.setTextSize(2);
    display.print(heart_rate);
  }
}

// initialize so don't have to calculate continuously
unsigned long hours{workout_time/(60UL*60*1000)};
unsigned long minutes{(workout_time % (60UL*60*1000)) / (60*1000UL)};
unsigned long seconds{(workout_time % (60UL*1000)) / 1000UL}; // not total seconds

void update_timer(){
	if (seconds > 0){
		--seconds;
	} else {
		if (minutes > 0){
			--minutes;
			seconds = 59;
		} else if (hours > 0){
			--hours;
			minutes = 59;
			seconds = 59;
		}
	}
}

void draw_timer(){
	display.setTextSize(2);

	// kind of repetitive
	display.setCursor(67, 0);
	if (hours < 10)
		display.print("0");
	display.print(hours);
	display.print(":");

	if (minutes < 10)
		display.print("0");
	display.print(minutes);
	display.print(":");

	display.setCursor(103, 16);
	if (seconds < 10)
	display.print("0");
	display.print(seconds);
}

void update_reps(){
	display.setCursor(67, 32);
	display.print("Reps: ");
	display.setCursor(103, 48);
	display.print(reps);
}